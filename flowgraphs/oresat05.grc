options:
  parameters:
    author: GlennL & KennyM
    comment: |-
      ~
      See:
      https://github.com/oresat/uniclogs-sdr/flowgraphs
    generate_options: no_gui
    id: OreSat0
    output_language: python
    run_options: run
    title: UHF G3RUH & EDL Receiver / UHF -or- L-Band EDL Transmitter
  states: {}

blocks:
- name: beacon_host
  id: variable_config
  parameters:
    config_file: conf
    option: telemetry_host
    section: main
    type: string
    value: localhost
    writeback: None
  states: {}
- name: edl_host
  id: variable_config
  parameters:
    config_file: conf
    option: command_host
    section: main
    type: string
    value: localhost
    writeback: None
  states: {}
- name: f_offset
  id: variable
  parameters:
    comment: |-
      Pick out our RF
      carrier in the Rx
      bandwidth
    value: rx_samp_rate/4
  states: {}
- name: gpredict_rx_frequency
  id: variable
  parameters:
    value: rx_target_frequency
  states: {}
- name: gpredict_tx_frequency
  id: variable
  parameters:
    value: tx_center_frequency
  states: {}
- name: main_samp_per_sym
  id: variable_config
  parameters:
    config_file: conf
    option: samples_per_symbol
    section: main
    type: int
    value: '4'
    writeback: None
  states: {}
- name: morse_bump
  id: variable
  parameters:
    value: '0'
  states: {}
- name: morse_call
  id: variable_config
  parameters:
    config_file: conf
    option: morse_callsign
    section: main
    type: string
    value: KJ7SAT
    writeback: None
  states: {}
- name: occupied_bandwidth
  id: variable
  parameters:
    value: tx_bit_rate * tx_modulation_index
  states: {}
- name: rx_beacon_bit_rate
  id: variable_config
  parameters:
    config_file: conf
    option: bit_rate
    section: rx_beacon
    type: int
    value: '9600'
    writeback: None
  states: {}
- name: rx_device_serial
  id: variable_config
  parameters:
    config_file: conf
    option: device_serial
    section: rx
    type: string
    value: '0'
    writeback: None
  states: {}
- name: rx_edl_bit_rate
  id: variable_config
  parameters:
    config_file: conf
    option: bit_rate
    section: rx_edl
    type: int
    value: '96000'
    writeback: None
  states: {}
- name: rx_gain
  id: variable_config
  parameters:
    config_file: conf
    option: rx_gain
    section: rx
    type: int
    value: '35'
    writeback: None
  states: {}
- name: rx_iq_data_filename
  id: variable_config
  parameters:
    config_file: conf
    option: iq_filename
    section: rx
    type: string
    value: ''
    writeback: None
  states: {}
- name: rx_samp_rate
  id: variable_config
  parameters:
    config_file: conf
    option: sample_rate
    section: rx
    type: real
    value: 1.92e6
    writeback: None
  states: {}
- name: rx_target_frequency
  id: variable_config
  parameters:
    config_file: conf
    option: target_frequency
    section: rx
    type: real
    value: 436.5e6
    writeback: None
  states: {}
- name: rx_tune_frequency
  id: variable
  parameters:
    value: rx_target_frequency - f_offset
  states: {}
- name: tx_bit_rate
  id: variable_config
  parameters:
    config_file: conf
    option: bit_rate
    section: txband
    type: int
    value: '60000'
    writeback: None
  states: {}
- name: tx_center_frequency
  id: variable_config
  parameters:
    config_file: conf
    option: center_frequency
    section: txband
    type: real
    value: 1265e6
    writeback: None
  states: {}
- name: tx_channel
  id: variable_config
  parameters:
    config_file: conf
    option: channel
    section: txband
    type: int
    value: '0'
    writeback: None
  states: {}
- name: tx_deviation
  id: variable_config
  parameters:
    config_file: conf
    option: deviation
    section: txband
    type: int
    value: '20000'
    writeback: None
  states: {}
- name: tx_device_serial
  id: variable_config
  parameters:
    config_file: conf
    option: device_serial
    section: txband
    type: string
    value: '0'
    writeback: None
  states: {}
- name: tx_occupied_bandwidth
  id: variable
  parameters:
    value: tx_bit_rate+2*tx_deviation
  states: {}
- name: tx_offset
  id: variable
  parameters:
    value: 2 * tx_occupied_bandwidth
  states: {}
- name: tx_path
  id: variable_config
  parameters:
    config_file: conf
    option: path
    section: txband
    type: int
    value: '2'
    writeback: None
  states: {}
- name: tx_samp_rate
  id: variable_config
  parameters:
    config_file: conf
    option: sample_rate
    section: main
    type: real
    value: 2e6
    writeback: None
  states: {}
- name: tx_selector_options
  id: variable
  parameters:
    value: '[''cw'', ''edl'', ''morse'']'
  states: {}
- name: tx_tune_frequency
  id: variable
  parameters:
    value: tx_center_frequency - tx_offset
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    comment: Combine the offset tuning and doppler adjustments here
    freq: rx_tune_frequency - gpredict_rx_frequency
    offset: '0'
    phase: '0'
    samp_rate: rx_samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: gpredict_tx_frequency - tx_center_frequency + tx_offset
    offset: '0'
    phase: '0'
    samp_rate: tx_samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_1_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    comment: CW test source
    freq: '0'
    offset: '0'
    phase: '0'
    samp_rate: tx_samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: beacon_rx_bit_rate
  id: parameter
  parameters:
    label: Bit Rate
    type: intx
    value: '9600'
  states: {}
- name: beacon_rx_samp_rate
  id: parameter
  parameters:
    label: RF Sample Rate
    type: eng_float
    value: 1e6
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    comment: Option to save IQ data
    file: rx_iq_data_filename
    type: complex
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters:
    comment: Recovered APRS
  states: {}
- name: blocks_message_debug_0_0
  id: blocks_message_debug
  parameters:
    comment: Recovered EDL
  states: {}
- name: blocks_message_debug_0_0_0_0_0_0_1_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_msgpair_to_var_0
  id: blocks_msgpair_to_var
  parameters:
    target: gpredict_tx_frequency
  states: {}
- name: blocks_msgpair_to_var_2
  id: blocks_msgpair_to_var
  parameters:
    target: gpredict_rx_frequency
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_1
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_mute_xx_0_0
  id: blocks_mute_xx
  parameters:
    comment: |-
      Mute IQ data (do not save 
      to file) if filename is blank
    mute: bool(rx_iq_data_filename)
    type: complex
  states: {}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    comment: Reverse bit order
    endianness: gr.GR_MSB_FIRST
    k: '8'
    l: '8'
  states: {}
- name: blocks_repack_bits_bb_0_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '8'
    l: '8'
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: tx_selector_options.index(tx_selector)
    num_inputs: '3'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: blocks_tagged_stream_multiply_length_0_0
  id: blocks_tagged_stream_multiply_length
  parameters:
    c: main_samp_per_sym
    lengthtagname: packet_len
    type: complex
  states: {}
- name: blocks_var_to_msg_0
  id: blocks_var_to_msg
  parameters:
    msgname: msg
    target: morse_bump
  states: {}
- name: conf
  id: parameter
  parameters:
    label: config file
    short_id: c
    type: str
    value: OreSat0.cfg
  states: {}
- name: digital_descrambler_bb_0_0
  id: digital_descrambler_bb
  parameters:
    comment: |-
      https://destevez.net/2016/05/
      scramblers-and-their-implementation-in-gnuradio/
    len: '16'
    mask: '0x0021'
    seed: '0x0000'
  states: {}
- name: digital_descrambler_bb_0_0_0
  id: digital_descrambler_bb
  parameters:
    comment: |-
      https://destevez.net/2016/05/
      scramblers-and-their-implementation-in-gnuradio/
    len: '16'
    mask: '0x0021'
    seed: '0x0000'
  states: {}
- name: digital_gfsk_demod_0_0
  id: digital_gfsk_demod
  parameters:
    comment: |-
      Sensitivity from 
      textbook (whch ???)
    freq_error: '0.0'
    gain_mu: '0.175'
    mu: '0.5'
    omega_relative_limit: '0.0002'
    samples_per_symbol: main_samp_per_sym
    sensitivity: 2 * main_samp_per_sym / np.pi
  states: {}
- name: digital_gfsk_demod_0_0_0
  id: digital_gfsk_demod
  parameters:
    comment: |-
      Sensitivity from 
      textbook (whch ???)
    freq_error: '0.0'
    gain_mu: '0.175'
    mu: '0.5'
    omega_relative_limit: '0.0002'
    samples_per_symbol: main_samp_per_sym
    sensitivity: 2 * main_samp_per_sym / np.pi
  states: {}
- name: digital_gfsk_mod_0_0_0_0
  id: digital_gfsk_mod
  parameters:
    bt: tx_bt
    comment: |-
      Sensitivity calc from
      textbook (which???)
    do_unpack: 'False'
    samples_per_symbol: main_samp_per_sym
    sensitivity: np.pi * (tx_modulation_index - 1) / main_samp_per_sym
  states: {}
- name: digital_scrambler_bb_0_0_0_0
  id: digital_scrambler_bb
  parameters:
    comment: |-
      https://destevez.net/2016/05/
      scramblers-and-their-implementation-in-gnuradio/
    len: '16'
    mask: '0x21'
    seed: '0x0'
  states: {}
- name: edl_rx_bit_rate
  id: parameter
  parameters:
    label: Bit Rate
    type: intx
    value: '96000'
  states: {}
- name: edl_rx_samp_rate
  id: parameter
  parameters:
    label: RF Sample Rate
    type: eng_float
    value: 1.92e6
  states: {}
- name: fix_relative_paths
  id: epy_module
  parameters:
    source_code: |
      import os

      script_path = os.path.dirname(os.path.realpath(__file__))
      os.chdir(script_path)
  states: {}
- name: gpredict_doppler_0
  id: gpredict_doppler
  parameters:
    comment: |-
      Update RX frequency w/Doppler
      via XMLRPC
    gpredict_host: 0.0.0.0
    gpredict_port: '7356'
    verbose: 'False'
  states: {}
- name: gpredict_doppler_0_0
  id: gpredict_doppler
  parameters:
    comment: TX doppler
    gpredict_host: 0.0.0.0
    gpredict_port: '7358'
    verbose: 'False'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: beacon_rx_bit_rate*1.5
    decim: '1'
    gain: '1'
    samp_rate: beacon_rx_samp_rate
    type: fir_filter_ccf
    width: beacon_rx_bit_rate*0.75
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: edl_rx_bit_rate*1.5
    decim: '1'
    gain: '1'
    samp_rate: edl_rx_samp_rate
    type: fir_filter_ccf
    width: edl_rx_bit_rate*0.75
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: occupied_bandwidth * 1.2
    decim: '1'
    gain: '1'
    samp_rate: tx_samp_rate
    type: fir_filter_ccf
    width: tx_bit_rate
    win: window.WIN_HAMMING
  states: {}
- name: morse_hier_0
  id: morse_hier
  parameters:
    morse_dpw: '50'
    morse_wpm: '20'
    rf_samp_rate: tx_samp_rate
    verbose: 'True'
  states: {}
- name: multiply_constant
  id: parameter
  parameters:
    comment: This is experimental
    label: TX signal reducer
    short_id: m
    type: eng_float
    value: '.6'
  states: {}
- name: network_socket_pdu_0
  id: network_socket_pdu
  parameters:
    comment: Received APRS beacon
    host: beacon_host
    mtu: '10000'
    port: '10015'
    type: UDP_CLIENT
  states: {}
- name: network_socket_pdu_0_0_0_0
  id: network_socket_pdu
  parameters:
    comment: EDL to send
    host: 0.0.0.0
    mtu: '10000'
    port: '10025'
    type: UDP_SERVER
  states: {}
- name: network_socket_pdu_0_1
  id: network_socket_pdu
  parameters:
    comment: Received EDL response
    host: edl_host
    mtu: '10000'
    port: '10016'
    type: UDP_CLIENT
  states: {}
- name: note_0
  id: note
  parameters:
    note: TX magic below this point
  states: {}
- name: note_0_0
  id: note
  parameters:
    note: TX magic below this point
  states: {}
- name: note_0_1
  id: note
  parameters:
    note: TX magic below this point
  states: {}
- name: note_0_2
  id: note
  parameters:
    note: TX magic below this point
  states: {}
- name: note_0_3
  id: note
  parameters:
    note: TX magic below this point
  states: {}
- name: note_0_4
  id: note
  parameters:
    note: TX magic below this point
  states: {}
- name: note_0_5
  id: note
  parameters:
    note: TX magic below this point
  states: {}
- name: note_0_6
  id: note
  parameters:
    note: TX magic below this point
  states: {}
- name: note_0_7
  id: note
  parameters:
    note: TX magic below this point
  states: {}
- name: note_1
  id: note
  parameters:
    note: Config file variables below this point
  states: {}
- name: note_1_0
  id: note
  parameters:
    note: Config file variables below this point
  states: {}
- name: note_1_0_0
  id: note
  parameters:
    note: Config file variables below this point
  states: {}
- name: note_1_0_1
  id: note
  parameters:
    note: Config file variables below this point
  states: {}
- name: note_1_0_2
  id: note
  parameters:
    note: Config file variables below this point
  states: {}
- name: note_1_0_2_0
  id: note
  parameters:
    note: Config file variables below this point
  states: {}
- name: note_1_0_2_1
  id: note
  parameters:
    note: Config file variables below this point
  states: {}
- name: note_1_0_3
  id: note
  parameters:
    note: Config file variables below this point
  states: {}
- name: note_4
  id: note
  parameters:
    note: RX magic happens here
  states: {}
- name: note_4_0
  id: note
  parameters:
    note: RX magic happens here
  states: {}
- name: note_4_1
  id: note
  parameters:
    note: RX magic happens here
  states: {}
- name: note_4_2
  id: note
  parameters:
    note: RX magic happens here
  states: {}
- name: note_4_3
  id: note
  parameters:
    note: RX magic happens here
  states: {}
- name: note_4_4
  id: note
  parameters:
    note: RX magic happens here
  states: {}
- name: note_4_5
  id: note
  parameters:
    note: RX magic happens here
  states: {}
- name: note_4_6
  id: note
  parameters:
    note: RX magic happens here
  states: {}
- name: note_4_7
  id: note
  parameters:
    note: RX magic happens here
  states: {}
- name: note_4_8
  id: note
  parameters:
    note: RX magic happens here
  states: {}
- name: pdu_pdu_lambda_0
  id: pdu_pdu_lambda
  parameters:
    fn: 'lambda x: pmt.intern(morse_call)'
    metadict: Raw Message
  states: {}
- name: pdu_pdu_set_0
  id: pdu_pdu_set
  parameters:
    k: pmt.intern("note")
    v: pmt.intern("beacon")
  states: {}
- name: pdu_pdu_set_1
  id: pdu_pdu_set
  parameters:
    k: pmt.intern("note")
    v: pmt.intern("Received EDL")
  states: {}
- name: pdu_pdu_set_2
  id: pdu_pdu_set
  parameters:
    k: pmt.intern("note")
    v: pmt.intern("EDL to send")
  states: {}
- name: pdu_pdu_to_tagged_stream_0_0_0_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: int(beacon_rx_samp_rate)
    interp: beacon_rx_bit_rate * main_samp_per_sym
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0_0
  id: rational_resampler_xxx
  parameters:
    decim: int(edl_rx_samp_rate)
    interp: edl_rx_bit_rate * main_samp_per_sym
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_2_0_0_0_0_0
  id: rational_resampler_xxx
  parameters:
    decim: int(tx_bit_rate * main_samp_per_sym)
    interp: int(tx_samp_rate)
    taps: ''
    type: ccc
  states: {}
- name: satellites_hdlc_deframer_0_0
  id: satellites_hdlc_deframer
  parameters:
    check_fcs: 'False'
    comment: Make PDUs
    max_length: '300'
  states: {}
- name: satellites_hdlc_deframer_0_0_0
  id: satellites_hdlc_deframer
  parameters:
    check_fcs: 'True'
    max_length: '300'
  states: {}
- name: satellites_hdlc_framer_0_0_0_0
  id: satellites_hdlc_framer
  parameters:
    postamble_bytes: '16'
    preamble_bytes: '32'
  states: {}
- name: satellites_nrzi_decode_0_0
  id: satellites_nrzi_decode
  parameters: {}
  states: {}
- name: satellites_nrzi_decode_0_0_0
  id: satellites_nrzi_decode
  parameters: {}
  states: {}
- name: satellites_nrzi_encode_0_0_0_0
  id: satellites_nrzi_encode
  parameters: {}
  states: {}
- name: snippet_0
  id: snippet
  parameters:
    code: |-
      if self.get_tx_selector() == "morse":
          self.set_morse_bump(1)
    section: main_after_start
  states: {}
- name: tx_bt
  id: parameter
  parameters:
    comment: |-
      Set on CLI;
      Default = 0.5
    short_id: g
    type: eng_float
    value: '0.5'
  states: {}
- name: tx_gain
  id: parameter
  parameters:
    comment: |-
      Set on CLI
      Default = 30
    short_id: t
    type: intx
    value: '30'
  states: {}
- name: tx_modulation_index
  id: parameter
  parameters:
    comment: |-
      Chose based on 
      AX5043 radio lab
      weirdness
    label: Modulation index
    type: eng_float
    value: '1.666666'
  states: {}
- name: tx_selector
  id: parameter
  parameters:
    label: startup state of TX Selector (cw, edl, morse)
    short_id: s
    type: str
    value: edl
  states: {}
- name: txband
  id: parameter
  parameters:
    short_id: b
    type: str
    value: tx_l
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: tx_tune_frequency
    dev_addr: '"serial="+tx_device_serial'
    gain0: tx_gain
    samp_rate: tx_samp_rate
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: rx_tune_frequency
    comment: From the Ettus B200mini
    dev_addr: '"serial="+rx_device_serial'
    gain0: rx_gain
    samp_rate: rx_samp_rate
    sync: pc_clock
    type: fc32
  states: {}
- name: xmlrpc_server_0
  id: xmlrpc_server
  parameters:
    addr: 0.0.0.0
    port: '10080'
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [analog_sig_source_x_0_1, '0', blocks_multiply_xx_0_1, '0']
- [analog_sig_source_x_0_1_0, '0', blocks_selector_0, '0']
- [blocks_multiply_xx_0, '0', low_pass_filter_0_0, '0']
- [blocks_multiply_xx_0, '0', low_pass_filter_0_0_0, '0']
- [blocks_multiply_xx_0_1, '0', uhd_usrp_sink_0, '0']
- [blocks_mute_xx_0_0, '0', blocks_file_sink_0, '0']
- [blocks_repack_bits_bb_0, '0', satellites_hdlc_deframer_0_0_0, '0']
- [blocks_repack_bits_bb_0_0, '0', digital_scrambler_bb_0_0_0_0, '0']
- [blocks_selector_0, '0', blocks_multiply_xx_0_1, '1']
- [blocks_tagged_stream_multiply_length_0_0, '0', rational_resampler_xxx_2_0_0_0_0_0, '0']
- [blocks_var_to_msg_0, msgout, pdu_pdu_lambda_0, pdu]
- [digital_descrambler_bb_0_0, '0', blocks_repack_bits_bb_0, '0']
- [digital_descrambler_bb_0_0_0, '0', satellites_hdlc_deframer_0_0, '0']
- [digital_gfsk_demod_0_0, '0', satellites_nrzi_decode_0_0, '0']
- [digital_gfsk_demod_0_0_0, '0', satellites_nrzi_decode_0_0_0, '0']
- [digital_gfsk_mod_0_0_0_0, '0', blocks_tagged_stream_multiply_length_0_0, '0']
- [digital_scrambler_bb_0_0_0_0, '0', satellites_nrzi_encode_0_0_0_0, '0']
- [gpredict_doppler_0, freq, blocks_msgpair_to_var_2, inpair]
- [gpredict_doppler_0_0, freq, blocks_msgpair_to_var_0, inpair]
- [low_pass_filter_0_0, '0', rational_resampler_xxx_0_0, '0']
- [low_pass_filter_0_0_0, '0', rational_resampler_xxx_0_0_0, '0']
- [low_pass_filter_0_0_0_0, '0', blocks_selector_0, '1']
- [morse_hier_0, '0', blocks_selector_0, '2']
- [network_socket_pdu_0_0_0_0, pdus, pdu_pdu_set_2, pdus]
- [network_socket_pdu_0_0_0_0, pdus, satellites_hdlc_framer_0_0_0_0, in]
- [pdu_pdu_lambda_0, pdu, morse_hier_0, msg_in]
- [pdu_pdu_set_0, pdus, blocks_message_debug_0, print]
- [pdu_pdu_set_1, pdus, blocks_message_debug_0_0, print]
- [pdu_pdu_set_2, pdus, blocks_message_debug_0_0_0_0_0_0_1_0, print]
- [pdu_pdu_to_tagged_stream_0_0_0_0, '0', blocks_repack_bits_bb_0_0, '0']
- [rational_resampler_xxx_0_0, '0', digital_gfsk_demod_0_0, '0']
- [rational_resampler_xxx_0_0_0, '0', digital_gfsk_demod_0_0_0, '0']
- [rational_resampler_xxx_2_0_0_0_0_0, '0', low_pass_filter_0_0_0_0, '0']
- [satellites_hdlc_deframer_0_0, out, network_socket_pdu_0, pdus]
- [satellites_hdlc_deframer_0_0, out, pdu_pdu_set_0, pdus]
- [satellites_hdlc_deframer_0_0_0, out, network_socket_pdu_0_1, pdus]
- [satellites_hdlc_deframer_0_0_0, out, pdu_pdu_set_1, pdus]
- [satellites_hdlc_framer_0_0_0_0, out, pdu_pdu_to_tagged_stream_0_0_0_0, pdus]
- [satellites_nrzi_decode_0_0, '0', digital_descrambler_bb_0_0_0, '0']
- [satellites_nrzi_decode_0_0_0, '0', digital_descrambler_bb_0_0, '0']
- [satellites_nrzi_encode_0_0_0_0, '0', digital_gfsk_mod_0_0_0_0, '0']
- [uhd_usrp_source_0, '0', blocks_multiply_xx_0, '0']
- [uhd_usrp_source_0, '0', blocks_mute_xx_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
